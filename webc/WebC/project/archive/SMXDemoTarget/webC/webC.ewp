# IAR project webC.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LPC2478 NXP LPC2478
  ICCARM.CCDefines: IAR_LPC_2478_STK; __WEBC__; WEBC_SUPPORT_JSCRIPT=1; WEBC_SUPPORT_UNICODE=0
  ICCARM.CCIncludePath2: ..\..\..\include\protocol; ..\..\..\include\util; ..\..\..\include\minigui; ..\..\..\include\jscript; ..\..\..\include\imgconvert; ..\..\..\include\imgdecode; ..\..\..\include\htmldom; ..\..\..\include\htmldisplay; ..\..\..\include\browser; ..\..\..\html\include; ..\..\..\lib\libjpeg; ..\..\..\lib\zlib; ..\..\..\lib\libmng; ..\..\..\lib\libpng; ..\..\..\..\..\rtplatform\v0.4\include\segger; ..\..\..\..\..\rtplatform\v0.4\include; ..\..\..\lib\mozilla; ..\..\..\gui\framebuffer\include\; ..\..\..\gui\framebuffer\FB_Graphics\include\; ..\..\..\gui\framebuffer\FB_Fonts\; ..\board
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  OBJCOPY.OOCOutputFile: 5.srec
  ILINK.IlinkOutputFile: webC.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; IAR_LPC_2478_STK; __WEBC__; WEBC_SUPPORT_JSCRIPT=1; WEBC_SUPPORT_UNICODE=0
  ICCARM.CCIncludePath2: ..\..\..\include\protocol; ..\..\..\include\util; ..\..\..\include\minigui; ..\..\..\include\jscript; ..\..\..\include\imgconvert; ..\..\..\include\imgdecode; ..\..\..\include\htmldom; ..\..\..\include\htmldisplay; ..\..\..\include\browser; ..\..\..\html\include; ..\..\..\lib\libjpeg; ..\..\..\lib\zlib; ..\..\..\lib\libmng; ..\..\..\lib\libpng; ..\..\..\..\..\rtplatform\v0.4\include\segger; ..\..\..\..\..\rtplatform\v0.4\include; ..\..\..\lib\mozilla; ..\..\..\gui\framebuffer\include\; ..\..\..\gui\framebuffer\FB_Graphics\include\; ..\..\..\gui\framebuffer\FB_Fonts\; ..\TouchDemoPP\board
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  group Include/browser
    ../../../include/browser/: enum.hpp htmlbrow.hpp htmldoc.hpp largeint.h wcfilter.hpp wcstream.hpp
  group Include/frame_buffer
    ../../../gui/framebuffer/FB_Graphics/include/: FB_Graphics.h FB_List.h FB_List_Iterator.h FB_Window.h FB_Window_Manager.h Filters.h
    ../../../gui/framebuffer/include/: FBAbstraction.h FBAbstractionFonts.h
  group Include/frame_buffer/Fonts
    ../../../gui/framebuffer/FB_Fonts/: ArialRegular9.h
  group Include/htmldisplay
    ../../../include/htmldisplay/: dcontent.hpp dflow.hpp dharea.hpp dhbody.hpp dhbutton.hpp dhcheck.hpp dhedbox.hpp dhedit.hpp dhedstr.hpp dhelem.hpp dhframe.hpp dhframeset.hpp dhhr.hpp dhibutton.hpp dhiframe.hpp dhimg.hpp dhli.hpp dhpasswd.hpp dhradio.hpp dhselect.hpp dhstring.hpp dhtable.hpp dhtd.hpp dhtumirror.hpp format.hpp formatctx.hpp keycatch.hpp margins.hpp textunit.hpp tuenum.hpp tulist.hpp zdelem.hpp
  group Include/htmldom
    ../../../include/htmldom/: haddress.hpp hanchor.hpp harea.hpp hbase.hpp hbig.hpp hblquote.hpp hbody.hpp hbold.hpp hbr.hpp hbutton.hpp hcbox.hpp hcenter.hpp hchkbox.hpp hcite.hpp hcode.hpp hdd.hpp hdel.hpp hdiv.hpp hdl.hpp hdstream.hpp hdt.hpp hedit.hpp helement.hpp hemphsz.hpp heventce.hpp hflow.hpp hfont.hpp hform.hpp hframe.hpp hframset.hpp hheading.hpp hhidden.hpp hhr.hpp hibutton.hpp hiframe.hpp himage.hpp hinput.hpp hins.hpp hitalic.hpp hkbd.hpp hlabel.hpp hli.hpp hlist.hpp hmap.hpp hnobr.hpp hoption.hpp hpara.hpp hpasswd.hpp hpre.hpp hradio.hpp hreset.hpp hscript.hpp hselect.hpp hsmall.hpp hspacer.hpp hspan.hpp hstrike.hpp hstring.hpp hstrong.hpp hsubmit.hpp htable.hpp htd.hpp htmlbld.hpp htmldom.hpp htmlfind.hpp htr.hpp htxtarea.hpp hundline.hpp textstyle.hpp urldesc.hpp xmlutil.h
  group Include/imgconvert
    ../../../include/imgconvert/: 24to24.hpp 24to32.hpp 24to555.hpp 24to565.hpp 24to8.hpp 24togs.hpp 32to24.hpp 8to24.hpp 8to32.hpp 8to555.hpp 8to565.hpp 8to8.hpp 8togs.hpp gs8togs.hpp imgconv.hpp
  group Include/imgdecode
    ../../../include/imgdecode/: bmpdec.h webbmp.hpp webcbmp.hpp webgif.hpp webimage.hpp webjpeg.hpp webload.hpp webmng.hpp webpng.hpp
  group Include/jscript
    ../../../include/jscript/: jevent.h jhanchor.h jharea.h jhbody.h jhbutton.h jhcoll.h jhdoc.h jhelem.h jhflow.h jhform.h jhframe.h jhfrset.h jhiframe.h jhimg.h jhinput.h jhistory.h jhmap.h jhoption.h jhselect.h jhtable.h jhtarea.h jhtblrow.h jhtcell.h jhtitle.h jhutils.h jloc.h jnav.h jrule.h jsobjref.hpp jssheet.h jstyle.h jwindow.h wjsbrowser.h wjscript.hpp wjsdebug.h wjsdoc.h
  group Include/minigui
    ../../../include/minigui/: delement.hpp dmanager.hpp webgraph.hpp wgbmp.hpp wgcolors.hpp wgkeys.hpp wgtypes.hpp wtbutton.hpp wtcheck.hpp wtdrop.hpp wtedbox.hpp wtedstr.hpp wtlist.hpp wtpasswd.hpp wtradio.hpp wtscroll.hpp wtslider.hpp
  group Include/protocol
    ../../../include/protocol/: cookie.h fileext.h httpc.h protfile.h prothssl.h prothttp.h protoffl.h sramdisk.hpp webcbig5.h webceuckr.h webcGb2312.h webcsjis.h webcsock.h webvfile.hpp
  group Include/util
    ../../../include/util/: buffer.h css.h cssborder.h dbgtimer.h dllist.h filetype.h hashtbl.hpp html.h htmlsdk.h listener.hpp objref.cpp ref.hpp refcount.hpp strbld.hpp strtable.hpp template.h util.h vector.h wcache.h wcconst.hpp webc.h webcassert.h webcdefault.h webcfg.h webcfile.h webcinline.h webcLog.h webcmem.h webcstr.h webctmo.h webctypes.h webcutf.h webfonts.hpp webrect.hpp webstr.hpp xml.h
  group Source/browser
    ../../../source/browser/: bowsertestsuite.cpp dbgtimer.c htmlbrow.cpp htmldoc.cpp htmlsdk.cpp webc.cpp
  group Source/content
    ../../../html/source/: browsericon.c ebslogo.c welcome.c
  group Source/frame_buffer
    ../../../gui/framebuffer/source/: FBAbstraction.cpp FBAbstractionFonts.cpp FBGraphicsContext.cpp LPC2478FrameBuffer.cpp
    ../../../gui/framebuffer/FB_Graphics/source/: Filters.cpp
  group Source/frame_buffer/Fonts
    ../../../gui/framebuffer/FB_Fonts/: ArialBold10.c ArialBold6.c ArialBold9.c ArialItalic10.c ArialItalic6.c ArialItalic9.c ArialRegular10.c ArialRegular6.c ArialRegular9.c
  group Source/htmldisplay
    ../../../source/htmldisplay/: dcontent.cpp dflow.cpp dharea.cpp dhbody.cpp dhbutton.cpp dhcheck.cpp dhedbox.cpp dhedit.cpp dhedstr.cpp dhelem.cpp dhframe.cpp dhframeset.cpp dhhr.cpp dhibutton.cpp dhiframe.cpp dhimg.cpp dhli.cpp dhpasswd.cpp dhradio.cpp dhselect.cpp dhstring.cpp dhtable.cpp dhtd.cpp dhtumirror.cpp format.cpp formatctx.cpp keycatch.cpp margins.cpp tuenum.cpp tulist.cpp zdelem.cpp
  group Source/htmldom
    ../../../source/htmldom/: css.cpp haddress.cpp hanchor.cpp harea.cpp hbase.cpp hbig.cpp hblquote.cpp hbody.cpp hbold.cpp hbr.cpp hbutton.cpp hcbox.cpp hcenter.cpp hchkbox.cpp hcite.cpp hcode.cpp hdd.cpp hdel.cpp hdiv.cpp hdl.cpp hdstream.cpp hdt.cpp hedit.cpp helement.cpp hemphsz.cpp hflow.cpp hfont.cpp hform.cpp hframe.cpp hframset.cpp hheading.cpp hhidden.cpp hhr.cpp hibutton.cpp hiframe.cpp himage.cpp hinput.cpp hins.cpp hitalic.cpp hkbd.cpp hlabel.cpp hli.cpp hlist.cpp hmap.cpp hnobr.cpp hoption.cpp hpara.cpp hpasswd.cpp hpre.cpp hradio.cpp hreset.cpp hscript.cpp hselect.cpp hsmall.cpp hspacer.cpp hspan.cpp hstrike.cpp hstring.cpp hstrong.cpp hsubmit.cpp htable.cpp htd.cpp html.c htmlbld.cpp htmldom.cpp htmlfind.cpp htr.cpp htxtarea.cpp hundline.cpp textstyle.cpp urldesc.cpp xml.c xmlutil.c
  group Source/imgconvert
    ../../../source/imgconvert/: 24to24.cpp 24to32.cpp 24to555.cpp 24to565.cpp 24to8.cpp 24togs.cpp 32to24.cpp 8to24.cpp 8to32.cpp 8to555.cpp 8to565.cpp 8to8.cpp 8togs.cpp gs8togs.cpp imgconv.cpp
  group Source/imgdecode
    ../../../source/imgdecode/: bmpdec.c webbmp.cpp webcbmp.cpp webgif.cpp webimage.cpp webjpeg.cpp webmng.cpp webpng.cpp
  group Source/jscript
    ../../../source/jscript/: jevent.cpp jhanchor.cpp jharea.cpp jhbody.cpp jhbutton.cpp jhcoll.cpp jhdoc.cpp jhelem.cpp jhflow.cpp jhform.cpp jhframe.cpp jhfrset.cpp jhiframe.cpp jhimg.cpp jhinput.cpp jhistory.cpp jhmap.cpp jhoption.cpp jhselect.cpp jhtable.cpp jhtarea.cpp jhtblrow.cpp jhtcell.cpp jhtitle.cpp jhutils.cpp jloc.cpp jnav.cpp jrule.cpp jsobjref.cpp jssheet.cpp jstyle.cpp jwindow.cpp wjdialogs.cpp wjsbrowser.cpp wjscript.cpp wjsdebug.cpp wjsdoc.cpp
  group Source/minigui
    ../../../source/minigui/: delement.cpp dmanager.cpp TestWidgits.cpp webcdefault.cpp webgraph.cpp wgbmp.cpp wtbutton.cpp wtcheck.cpp wtdrop.cpp wtedbox.cpp wtedstr.cpp wtlist.cpp wtpasswd.cpp wtradio.cpp wtscroll.cpp wtslider.cpp
  group Source/protocol
    ../../../source/protocol/: cookie.c fileext.c filetype.c httpc.c protfile.cpp prothssl.cpp prothttp.cpp protoffl.cpp sramdisk.cpp wcfilter.cpp wcstream.cpp webcbig5.cpp webceuckr.cpp webcgb2312.cpp webcsjis.cpp webcsock.c webcutf.cpp webload.cpp webvfile.cpp
  group Source/util
    ../../../source/util/: buffer.c hashtbl.cpp ref.cpp refcount.cpp strbld.cpp strtable.cpp template.c util.c vector.c wcache.cpp wcconst.cpp webcfile.c webcLog.cpp webcmem.cpp webcstr.cpp webctmo.cpp webfonts.cpp webrect.cpp webstr.cpp
