# IAR project rtPlatform.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LPC2478 NXP LPC2478
  ICCARM.CCIncludePath2: ..\..\..\..\..\rtplatform\v0.4\include\smx; ..\..\..\..\..\rtplatform\v0.4\include; ..\..\..\..\..\SMX\XNS\include; ..\..\..\..\..\SMX\XSMX\; ..\..\..\..\..\SMX\XFS\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: 5.srec
  ILINK.IlinkOutputFile: rtPlatform.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: ..\..\..\..\..\rtplatform\v0.4\include\smx; ..\..\..\..\..\rtplatform\v0.4\include; $TOOLKIT_DIR$\PowerPac\TCPIP\Inc; $TOOLKIT_DIR$\PowerPac\RTOS\inc
  ICCARM.CCOptLevel: 3
  group Include
    ../../../../../rtplatform/v0.4/include/: rtp.h rtpbsearch.h rtpchar.h rtpdate.h rtpdebug.h rtpdllist.h rtpdobj.h rtpdutil.h rtpenv.h rtpexit.h rtpfile.h rtpfio.h rtphelper.h rtpirq.h rtpkern.h rtpmem.h rtpmemdb.h rtpmtxdb.h rtpnet.h rtpnetsm.h rtppbuf.h rtppkt.h rtpprint-generic.h rtpqsort.h rtprand.h rtprot.h rtpscnv.h rtpsemdb.h rtpsignl.h rtpssl.h rtpstdup.h rtpstr.h rtpterm.h rtpthrd.h rtptime.h rtptimer.h rtptotc.h rtptypes.h rtpwchar.h rtpwcs.h rtpwfile.h rtpwscnv.h
  group Source
    ../../../../../rtplatform/v0.4/source/generic/: rtpchar.c rtpdutil.c rtpmemdb.c rtprand.c rtpscnv.c rtpstr.c rtpwchar.c rtpwcs.c rtpwscnv.c
  group Source/SMX_specific
    ../../../../../rtplatform/v0.4/source/SMX/: rtpdate.c rtpdobj.c rtpfile.c rtpmem.c rtpnet.c rtpthrd.c rtptime.c
