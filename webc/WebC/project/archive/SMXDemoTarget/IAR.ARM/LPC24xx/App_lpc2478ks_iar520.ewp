# IAR project App_lpc2478ks_iar520.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LPC2478 NXP LPC2478
  ICCARM.CCDefines: IAR_LPC_2478_STK=1; SMX_BT_DEBUG=1; SMX_TM=1
  ICCARM.PreInclude: ..\..\..\..\..\..\SMX\SHARED\IARARM.H
  ICCARM.CCIncludePath2: ..\..\; ..\..\..\..\..\..\SMX\SHARED\; ..\..\..\..\..\..\SMX\XSMX\; ..\..\..\..\..\..\SMX\XFS\; ..\..\LPC24xx\; ..\..\LPC24xx\IAR-LPC2478\; ..\..\..\..\..\..\SMX\XNS\include\; ..\..\..\..\include\protocol; ..\..\..\..\include\util; ..\..\..\..\include\minigui; ..\..\..\..\include\jscript; ..\..\..\..\include\imgconvert; ..\..\..\..\include\imgdecode; ..\..\..\..\include\htmldom; ..\..\..\..\include\htmldisplay; ..\..\..\..\include\browser; ..\..\..\..\html\include; ..\..\..\..\lib\libjpeg; ..\..\..\..\lib\zlib; ..\..\..\..\lib\libmng; ..\..\..\..\lib\libpng; ..\..\..\..\..\..\rtplatform\v0.4\include\smx; ..\..\..\..\..\..\rtplatform\v0.4\include; ..\..\..\..\lib\mozilla; ..\..\..\..\gui\framebuffer\include\; ..\..\..\..\gui\framebuffer\FB_Graphics\include\; ..\..\board\; ..\..\modules\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.ADefines: SMX_BT_DEBUG=1; TM=1; BOARD_IAR_LPC2478KS; PROCESSOR_LPC2478; PROCESSOR_LPC24XX
  AARM.AUserIncludes: ..\..\; ..\..\..\SHARED\; ..\..\..\XSMX\; ..\..\..\XSMXPP\; ..\..\LPC24xx\
  OBJCOPY.OOCOutputFile: App_lpc2478ks_iar520.srec
  ILINK.IlinkOutputFile: AppDbg.out
  ILINK.IlinkIcfFile: lpc2478ks_ram.icf
  ILINK.IlinkProgramEntryLabel: InitReset
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: SMX_BT_RELEASE=1; TM=1; NDEBUG
  ICCARM.PreInclude: ..\..\..\SHARED\IARARM.H
  ICCARM.CCIncludePath2: ..\..\; ..\..\..\SHARED\; ..\..\..\XSMX\; ..\..\..\XFS\; ..\..\LPC24xx\; ..\..\LPC24xx\IAR-LPC2478\; ..\..\..\XNS\include\
  ICCARM.CCOptLevel: 3
  AARM.ADefines: SMX_BT_RELEASE=1; TM=1; BOARD_IAR_LPC2478KS; PROCESSOR_LPC2478; PROCESSOR_LPC24XX
  AARM.AUserIncludes: ..\..\; ..\..\..\SHARED\; ..\..\LPC24xx\
  ILINK.IlinkOutputFile: AppRel.out
configuration ROM (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: SMX_BT_ROM=1; TM=1; NDEBUG
  ICCARM.PreInclude: ..\..\..\SHARED\IARARM.H
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  AARM.ADefines: SMX_BT_ROM=1; TM=1; BOARD_IAR_LPC2478KS; PROCESSOR_LPC2478; PROCESSOR_LPC24XX
  ILINK.IlinkOutputFile: AppRom.out
  ILINK.IlinkIcfFile: lpc2478ks_rom.icf
  group SMX Libraries
    ../../../../../../SMX/XFS/IAR.ARM/Release/: fst.a
    ../../../../../../SMX/XNS/IAR.ARM/Release/: nst.a
    ../../../../../../SMX/XSMX/IAR.ARM/Release/: smxt.a
  group Source
    ../../: APP.C LCD_Utils.c
  group Source/Config
    ../../: CONF.H
  group Source/IAR-LPC2478KS
    ../../LPC24xx/: boot_iar.s BSP.C UART.C
    ../../LPC24xx/IAR-LPC2478/: LED.C
  group Source/LCD Driver
    ../../: cursor_arrow.c
    ../../modules/: drv_glcd.c drv_touch_scr.c sdram_64M_32bit_drv.c
    ../../board/: sys.c
  group Source/Protosystem
    ../../LPC24xx/: BSPIAR.S
    ../../: CORE.C CRT.C ISRSHELS_IAR.S KBD.C
    ../../../../../../SMX/SHARED/: HEAP.C INITMODS.C RTL.C SMXAWARE.C
    ../../../../../../SMX/XSMX/: XESR.C XGOSMX.C XKEEPTIM.C
  group WebC Libraries
    ../../libjpeg/Debug/Exe/: libjpeg.a
    ../../libmng/Debug/Exe/: libmng.a
    ../../libpng/Debug/Exe/: libpng.a
    ../../mozjs/Debug/Exe/: mozjs.a
    ../../rtPlatform/Debug/Exe/: rtPlatform.a
    ../../webC/Debug/Exe/: webC.a
    ../../zlib/Debug/Exe/: zlib.a
