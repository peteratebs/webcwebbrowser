# IAR project zlib.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LPC2478 NXP LPC2478
  ICCARM.CCDefines: __WEBC__
  ICCARM.CCIncludePath2: ..\..\..\include\util; ..\..\..\..\..\rtplatform\v0.4\include\smx; ..\..\..\..\..\rtplatform\v0.4\include
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: 5.srec
  ILINK.IlinkOutputFile: zlib.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; __WEBC__
  ICCARM.CCOptLevel: 3
  group Include
    ../../../lib/zlib/: deflate.h infblock.h infcodes.h inffast.h inffixed.h inftrees.h infutil.h trees.h zconf.h zlib.h zutil.h
  group Source
    ../../../lib/zlib/: adler32.c compress.c crc32.c deflate.c gzio.c infblock.c infcodes.c inffast.c inflate.c inftrees.c infutil.c trees.c uncompr.c zutil.c
