# IAR project TouchDemoPP.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LPC2478 NXP LPC2478
  ICCARM.CCDefines: IAR_LPC_2478_STK; DEBUG=1; __WEBC__; WEBC_SUPPORT_JSCRIPT=1; WEBC_SUPPORT_UNICODE=0
  ICCARM.CCIncludePath2: app; rtos; board; modules; $TOOLKIT_DIR$\PowerPac\RTOS\inc; ..\..\..\include\protocol; ..\..\..\include\util; ..\..\..\include\minigui; ..\..\..\include\jscript; ..\..\..\include\imgconvert; ..\..\..\include\imgdecode; ..\..\..\include\htmldom; ..\..\..\include\htmldisplay; ..\..\..\include\browser; ..\..\..\html\include; ..\..\..\lib\libjpeg; ..\..\..\lib\zlib; ..\..\..\lib\libmng; ..\..\..\lib\libpng; ..\..\..\..\..\rtplatform\v0.4\include\smx; ..\..\..\..\..\rtplatform\v0.4\include; ..\..\..\lib\mozilla; ..\..\..\gui\framebuffer\include\; ..\..\..\gui\framebuffer\FB_Graphics\include\; $TOOLKIT_DIR$\PowerPac\TCPIP\Inc
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: TouchDemo.srec
  ILINK.IlinkOutputFile: LCD_Demo.out
  ILINK.IlinkIcfFile: config\LPC2478_Flash.icf
  ILINK.IlinkAdditionalLibs: ..\webC\Debug\Exe\webC.a; ..\rtPlatform\Debug\Exe\rtPlatform.a; ..\libjpeg\Debug\Exe\libjpeg.a; ..\mozjs\Debug\Exe\mozjs.a; ..\libpng\Debug\Exe\libpng.a; ..\zlib\Debug\Exe\zlib.a; $TOOLKIT_DIR$\PowerPac\TCPIP\Lib\ip4t_tl_id.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  ILINK.IlinkAdditionalLibs: ..\webC\Release\Exe\webC.a; ..\rtPlatform\Release\Exe\rtPlatform.a; ..\libjpeg\Release\Exe\libjpeg.a; ..\mozjs\Release\Exe\mozjs.a; ..\libpng\Release\Exe\libpng.a; ..\zlib\Release\Exe\zlib.a; $TOOLKIT_DIR$\PowerPac\TCPIP\Lib\ip4t_tl_ir.a
  group app
    app/: cursor_arrow.c IAR.c IP_Config_LPC24xx.c IP_ConfigIO.c main.cpp PowerPac.c Terminal_18_24x12.c
  group board
    board/: sys.c
  group config
    config/: LPC2478_Flash.icf
  group Modules
    modules/: drv_glcd.c drv_touch_scr.c sdram_32M_16bit_drv.c
  group RTOS
    rtos/: JLINKDCC_Process.c OS_Error.c RTOSINIT_LPC2478.c
    $EW_DIR$/arm/PowerPac/RTOS/Lib/: os4t_tl__d.a
  group Setup
    Setup/: BSP.c
