# IAR project libmng.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LPC2478 NXP LPC2478
  ICCARM.CCDefines: __WEBC__
  ICCARM.CCIncludePath2: ..\..\..\..\..\rtplatform\v0.4\include\smx; ..\..\..\..\..\rtplatform\v0.4\include; ..\..\..\lib\libjpeg; ..\..\..\lib\zlib
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: libmng.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; __WEBC__
  ICCARM.CCOptLevel: 3
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Include
    ../../../lib/libmng/: libmng.h libmng_chunk_io.h libmng_chunk_prc.h libmng_chunks.h libmng_cms.h libmng_conf.h libmng_data.h libmng_display.h libmng_dither.h libmng_error.h libmng_filter.h libmng_jpeg.h libmng_memory.h libmng_object_prc.h libmng_objects.h libmng_pixels.h libmng_read.h libmng_trace.h libmng_types.h libmng_write.h libmng_zlib.h
  group Source
    ../../../lib/libmng/: libmng_callback_xs.c libmng_chunk_io.c libmng_chunk_prc.c libmng_chunk_xs.c libmng_cms.c libmng_display.c libmng_dither.c libmng_error.c libmng_filter.c libmng_hlapi.c libmng_jpeg.c libmng_object_prc.c libmng_pixels.c libmng_prop_xs.c libmng_read.c libmng_trace.c libmng_write.c libmng_zlib.c
