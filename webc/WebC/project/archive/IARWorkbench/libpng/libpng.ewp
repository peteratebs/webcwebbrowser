# IAR project libpng.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LPC2478 NXP LPC2478
  ICCARM.CCDefines: __WEBC__
  ICCARM.CCIncludePath2: ..\..\..\..\..\rtplatform\v0.4\include\smx; ..\..\..\..\..\rtplatform\v0.4\include; ..\..\..\lib\zlib
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: 5.srec
  ILINK.IlinkOutputFile: libpng.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; __WEBC__
  ICCARM.CCOptLevel: 3
  group Include
    ../../../lib/libpng/: png.h pngasmrd.h pngconf.h
  group Source
    ../../../lib/libpng/: png.c pngerror.c pnggccrd.c pngget.c pngmem.c pngpread.c pngread.c pngrio.c pngrtran.c pngrutil.c pngset.c pngtrans.c pngvcrd.c pngwio.c pngwrite.c pngwtran.c pngwutil.c
