# IAR project mozjs.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LPC2478 NXP LPC2478
  ICCARM.CCDefines: WEBC_SUPPORT_JSCRIPT=1; __WEBC__
  ICCARM.CCIncludePath2: ..\..\..\include\util; ..\..\..\..\..\rtplatform\v0.4\include\smx; ..\..\..\..\..\rtplatform\v0.4\include
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: 5.srec
  ILINK.IlinkOutputFile: mozjs.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; WEBC_SUPPORT_JSCRIPT=1; __WEBC__
  ICCARM.CCOptLevel: 3
  group Include
    ../../../lib/mozilla/: jsapi.h jsarena.h jsarray.h jsatom.h jsbit.h jsbool.h jsclist.h jscntxt.h jscompat.h jsconfig.h jscpucfg.h jsdate.h jsdbgapi.h jsdhash.h jsdtoa.h jsemit.h jsexn.h jsfile.h jsfun.h jsgc.h jshash.h jsinterp.h jslibmath.h jslock.h jslong.h jsmath.h jsnum.h jsobj.h jsopcode.h jsosdep.h jsotypes.h jsparse.h jsprf.h jsprvtd.h jspubtd.h jsregexp.h jsscan.h jsscope.h jsscript.h jsstddef.h jsstr.h jstypes.h jsutil.h jsxdrapi.h jsxml.h prmjtime.h resource.h
  group Source
    ../../../lib/mozilla/: jsapi.c jsarena.c jsarray.c jsatom.c jsbool.c jscntxt.c jsdate.c jsdbgapi.c jsdhash.c jsdtoa.c jsemit.c jsexn.c jsfile.c jsfun.c jsgc.c jshash.c jsinterp.c jslock.c jslog2.c jslong.c jsmath.c jsnum.c jsobj.c jsopcode.c jsparse.c jsprf.c jsregexp.c jsscan.c jsscope.c jsscript.c jsstr.c jsutil.c jsxdrapi.c jsxml.c prmjtime.c
